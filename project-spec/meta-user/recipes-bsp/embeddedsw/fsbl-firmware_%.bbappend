YAML_BSP_CONFIG = "apu_as_overlay_config_master"
YAML_BSP_CONFIG[apu_as_overlay_config_master] = "set,true"
